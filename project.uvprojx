# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F767ZGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.12.0
  cpu: IRAM(0x20020000,0x60000) IRAM2(0x20000000,0x20000) IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F767xx, LFS_CONFIG=lfs_config.h, USE_HAL_DRIVER, RT_USING_ARM_LIBC
  c include: .;rt-thread\include;applications;.;board;board\CubeMX_Config\Inc;board\ports;libraries\HAL_Drivers;libraries\HAL_Drivers\config;libraries\HAL_Drivers\drv_flash;deca_application\inc;deca_driver\inc;packages\airkissOpen-latest;packages\at24cxx-latest;packages\fal-latest\inc;packages\filesystem_samples-latest;packages\littlefs-latest;packages\netutils-latest\telnet;packages\netutils-latest\tftp;.;packages\ota_downloader-latest;packages\rw007-latest;packages\rw007-latest\inc;packages\webclient-v2.0.1\inc;packages\webnet-latest\inc;USER\inc;rt-thread\libcpu\arm\common;rt-thread\libcpu\arm\cortex-m4;rt-thread\components\dfs\include;rt-thread\components\dfs\filesystems\devfs;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\spi;rt-thread\components\drivers\include;rt-thread\components\drivers\spi\sfud\inc;rt-thread\components\drivers\include;rt-thread\components\drivers\wlan;rt-thread\components\finsh;rt-thread\components\libc\compilers\armlibc;rt-thread\components\libc\compilers\common;rt-thread\components\net\lwip-2.1.0\src;rt-thread\components\net\lwip-2.1.0\src\include;rt-thread\components\net\lwip-2.1.0\src\arch\include;rt-thread\components\net\lwip-2.1.0\src\include\netif;rt-thread\components\net\netdev\include;rt-thread\components\net\sal_socket\include;rt-thread\components\net\sal_socket\include\socket;rt-thread\components\net\sal_socket\impl;rt-thread\components\net\sal_socket\include\dfs_net;rt-thread\components\net\sal_socket\include\dfs_net\sys_select;rt-thread\components\net\sal_socket\include\socket\sys_socket;libraries\STM32F7xx_HAL\STM32F7xx_HAL_Driver\Inc;libraries\STM32F7xx_HAL\CMSIS\Device\ST\STM32F7xx\Include;libraries\STM32F7xx_HAL\CMSIS\Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20020000 size 0x60000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: .\board\linker_scripts\link.sct
  group Kernel
    rt-thread/src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group Applications
    applications/: main.c
  group Drivers
    board/: board.c
    board/CubeMX_Config/Src/: stm32f7xx_hal_msp.c
    board/ports/: phy_reset.c spi_flash_init.c
    libraries/STM32F7xx_HAL/CMSIS/Device/ST/STM32F7xx/Source/Templates/arm/: startup_stm32f767xx.s
    libraries/HAL_Drivers/: drv_gpio.c drv_usart.c drv_spi.c drv_soft_i2c.c drv_eth.c drv_common.c
    libraries/HAL_Drivers/drv_flash/: drv_flash_f7.c
  group deca_application
    deca_application/src/: dw1000_driver.c dw1000_instance.c
  group deca_driver
    deca_driver/src/: deca_device.c deca_params_init.c deca_range_tables.c
  group airkissOpen
    packages/airkissOpen-latest/: airkiss.c
    packages/airkissOpen-latest/osdep/rtthread/: airkiss_demo.c
  group at24cxx
    packages/at24cxx-latest/: at24cxx.c
  group fal
    packages/fal-latest/src/: fal.c fal_flash.c fal_partition.c fal_rtt.c
    packages/fal-latest/samples/porting/: fal_flash_sfud_port.c
  group filesystem-samples
    packages/filesystem_samples-latest/: mkdir_sample.c
  group littlefs
    packages/littlefs-latest/: dfs_lfs.c lfs.c lfs_crc.c lfs_util.c
  group NetUtils
    packages/netutils-latest/telnet/: telnet.c
    packages/netutils-latest/tftp/: tftp_client.c tftp_port.c tftp_server.c tftp_xfer.c
  group ota_downloader
    packages/ota_downloader-latest/src/: http_ota.c
  group rw007
    packages/rw007-latest/src/: spi_wifi_rw007.c
    packages/rw007-latest/example/: rw007_stm32_port.c
  group WebClient
    packages/webclient-v2.0.1/src/: webclient.c webclient_file.c
  group WebNet
    packages/webnet-latest/src/: webnet.c wn_mimetype.c wn_request.c wn_session.c wn_utils.c wn_module.c md5.c
    packages/webnet-latest/module/: wn_module_asp.c wn_module_auth.c wn_module_cgi.c wn_module_index.c wn_module_alias.c wn_module_log.c wn_module_upload.c wn_module_ssi.c
    packages/webnet-latest/samples/: wn_sample.c wn_sample_upload.c
  group USER
    USER/src/: cJSON.c cJSON_Parse.c cpu_usage.c drv_usr.c dw1000_usr.c eeprom_var.c http_send.c net_app.c udp_send.c
  group cpu
    rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
  group Filesystem
    rt-thread/components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c poll.c select.c
    rt-thread/components/dfs/filesystems/devfs/: devfs.c
  group DeviceDrivers
    rt-thread/components/drivers/cputime/: cputime.c cputime_cortexm.c
    rt-thread/components/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
    rt-thread/components/drivers/misc/: pin.c
    rt-thread/components/drivers/mtd/: mtd_nor.c
    rt-thread/components/drivers/rtc/: rtc.c
    rt-thread/components/drivers/serial/: serial.c
    rt-thread/components/drivers/spi/: spi_core.c spi_dev.c spi_flash_sfud.c
    rt-thread/components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    rt-thread/components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/wlan/: wlan_dev.c wlan_mgnt.c wlan_cmd.c wlan_prot.c wlan_lwip.c wlan_cfg.c wlan_workqueue.c
  group finsh
    rt-thread/components/finsh/: shell.c symbol.c cmd.c msh.c msh_cmd.c msh_file.c
  group libc
    rt-thread/components/libc/compilers/armlibc/: libc.c mem_std.c stdio.c stubs.c
    rt-thread/components/libc/compilers/common/: time.c
  group lwIP
    rt-thread/components/net/lwip-2.1.0/src/arch/: sys_arch.c
    rt-thread/components/net/lwip-2.1.0/src/core/: init.c def.c dns.c inet_chksum.c ip.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c altcp.c altcp_alloc.c altcp_tcp.c
    rt-thread/components/net/lwip-2.1.0/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    rt-thread/components/net/lwip-2.1.0/src/netif/: ethernet.c ethernetif.c lowpan6.c
    rt-thread/components/net/lwip-2.1.0/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4_frag.c ip4.c ip4_addr.c
    rt-thread/components/net/lwip-2.1.0/src/apps/ping/: ping.c
  group netdev
    rt-thread/components/net/netdev/src/: netdev.c netdev_ipaddr.c
  group SAL
    rt-thread/components/net/sal_socket/src/: sal_socket.c
    rt-thread/components/net/sal_socket/socket/: net_netdb.c net_sockets.c
    rt-thread/components/net/sal_socket/impl/: af_inet_lwip.c
    rt-thread/components/net/sal_socket/dfs_net/: dfs_net.c
  group STM32_HAL
    libraries/STM32F7xx_HAL/CMSIS/Device/ST/STM32F7xx/Source/Templates/: system_stm32f7xx.c
    libraries/STM32F7xx_HAL/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_cec.c stm32f7xx_hal_cortex.c stm32f7xx_hal_crc.c stm32f7xx_hal_cryp.c stm32f7xx_hal_cryp_ex.c stm32f7xx_hal_exti.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_rng.c stm32f7xx_hal_sram.c stm32f7xx_hal_gpio.c stm32f7xx_hal_uart.c stm32f7xx_hal_uart_ex.c stm32f7xx_hal_usart.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_spi.c stm32f7xx_hal_spi_ex.c stm32f7xx_hal_qspi.c stm32f7xx_hal_eth.c stm32f7xx_hal_rtc.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_nor.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c
